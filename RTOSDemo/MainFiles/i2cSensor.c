#include <stdlib.h>
#include <stdio.h>
#include <math.h>
#include <string.h>

/* Scheduler include files. */
#include "FreeRTOS.h"
#include "task.h"
#include "projdefs.h"
#include "semphr.h"

/* include files. */
#include "vtUtilities.h"
#include "vtI2C.h"
#include "LCDtask.h"
#include "i2cSensor.h"
#include "I2CTaskMsgTypes.h"

/* *********************************************** */
// definitions and data structures that are private to this file
// Length of the queue to this task
#define vtSensorQLen 10 
// actual data structure that is sent in a message
typedef struct __vtSensorMsg {
	uint8_t msgType;
	uint8_t	length;	 // Length of the message to be printed
	uint8_t buf[vtSensorMaxLen+1]; // On the way in, message to be sent, on the way out, message received (if any)
} vtSensorMsg;

// I have set this to a large stack size because of (a) using printf() and (b) the depth of function calls
//   for some of the i2c operations	-- almost certainly too large, see LCDTask.c for details on how to check the size
#define baseStack 3
#if PRINTF_VERSION == 1
#define i2cSTACK_SIZE		((baseStack+5)*configMINIMAL_STACK_SIZE)
#else
#define i2cSTACK_SIZE		(baseStack*configMINIMAL_STACK_SIZE)
#endif

// end of defs
/* *********************************************** */

/* The i2cSensor task. */
static portTASK_FUNCTION_PROTO( vi2cSensorUpdateTask, pvParameters );

/*-----------------------------------------------------------*/
// Public API
void vStarti2cSensorTask(vtSensorStruct *params,unsigned portBASE_TYPE uxPriority, vtI2CStruct *i2c,vtLCDStruct *lcd)
{
	// Create the queue that will be used to talk to this task
	if ((params->inQ = xQueueCreate(vtSensorQLen,sizeof(vtSensorMsg))) == NULL) {
		VT_HANDLE_FATAL_ERROR(0);
	}
	/* Start the task */
	portBASE_TYPE retval;
	params->dev = i2c;
	params->lcdData = lcd;
	if ((retval = xTaskCreate( vi2cSensorUpdateTask, ( signed char * ) "i2cSensor", i2cSTACK_SIZE, (void *) params, uxPriority, ( xTaskHandle * ) NULL )) != pdPASS) {
		VT_HANDLE_FATAL_ERROR(retval);
	}
}

portBASE_TYPE SendSensorTimerMsg(vtSensorStruct *sensorData,portTickType ticksElapsed,portTickType ticksToBlock)
{
	if (sensorData == NULL) {
		VT_HANDLE_FATAL_ERROR(0);
	}
	vtSensorMsg sensorBuffer;
	sensorBuffer.length = sizeof(ticksElapsed);
	if (sensorBuffer.length > vtSensorMaxLen) {
		// no room for this message
		VT_HANDLE_FATAL_ERROR(sensorBuffer.length);
	}
	memcpy(sensorBuffer.buf,(char *)&ticksElapsed,sizeof(ticksElapsed));
	sensorBuffer.msgType = SensorMsgTypeTimer;
	return(xQueueSend(sensorData->inQ,(void *) (&sensorBuffer),ticksToBlock));
}

portBASE_TYPE SendSensorValueMsg(vtSensorStruct *SensorData,uint8_t msgType,uint8_t value,portTickType ticksToBlock)
{
	vtSensorMsg SensorBuffer;

	if (SensorData == NULL) {
		VT_HANDLE_FATAL_ERROR(0);
	}
	SensorBuffer.length = sizeof(value);
	if (SensorBuffer.length > vtSensorMaxLen) {
		// no room for this message
		VT_HANDLE_FATAL_ERROR(SensorBuffer.length);
	}
	memcpy(SensorBuffer.buf,(char *)&value,sizeof(value));
	SensorBuffer.msgType = msgType;
	return(xQueueSend(SensorData->inQ,(void *) (&SensorBuffer),ticksToBlock));
}

// End of Public API
/*-----------------------------------------------------------*/
int getMsgType(vtSensorMsg *Buffer)
{
	return(Buffer->msgType);
}
uint8_t getValue(vtSensorMsg *Buffer)
{
	uint8_t *ptr = (uint8_t *) Buffer->buf;
	return(*ptr);
}

// I2C commands for the infrared sensor
	const uint8_t i2cCmdInit[]= {0xAC,0x00};
	const uint8_t i2cCmdStartConvert[]= {0xEE};
	const uint8_t i2cCmdStopConvert[]= {0x22};
	const uint8_t i2cCmdReadVals[]= {0xBB};

// end of I2C command definitions

// Definitions of the states for the FSM below
const uint8_t fsmStateInit1Sent = 0;
const uint8_t fsmStateInit2Sent = 1;
const uint8_t fsmStateSensorRead1 = 2;

// This is the actual task that is run
static portTASK_FUNCTION( vi2cSensorUpdateTask, pvParameters )
{
	float distance = 0.0;
	// Get the parameters
	vtSensorStruct *param = (vtSensorStruct *) pvParameters;
	// Get the I2C device pointer
	vtI2CStruct *devPtr = param->dev;
	// Get the LCD information pointer
	vtLCDStruct *lcdData = param->lcdData;
	// String buffer for printing
	char lcdBuffer[vtLCDMaxLen+1];
	// Buffer for receiving messages
	vtSensorMsg msgBuffer;
	uint8_t currentState;

	// Assumes that the I2C device (and thread) have already been initialized

	// This task is implemented as a Finite State Machine.  The incoming messages are examined to see
	//   whether or not the state should change.
	//
	// Infrared sensor configuration sequence (DS1621) Address 0x4F
	if (vtI2CEnQ(devPtr,vtI2CMsgTypeSensorInit,0x4F,sizeof(i2cCmdInit),i2cCmdInit,0) != pdTRUE) {
		VT_HANDLE_FATAL_ERROR(0);
	}
	currentState = fsmStateInit1Sent;
	// Like all good tasks, this should never exit
	for(;;)
	{
		// Wait for a message from either a timer or from an I2C operation
		if (xQueueReceive(param->inQ,(void *) &msgBuffer,portMAX_DELAY) != pdTRUE) {
			VT_HANDLE_FATAL_ERROR(0);
		}

		// Now, based on the type of the message and the state, we decide on the new state and action to take
		switch(getMsgType(&msgBuffer)) {
		case vtI2CMsgTypeSensorInit: {
			if (currentState == fsmStateInit1Sent) {
				currentState = fsmStateInit2Sent;
				// Must wait 10ms after writing to the infrared sensor's configuration registers(per sensor data sheet)
				vTaskDelay(10/portTICK_RATE_MS);
				// Tell it to start converting
				if (vtI2CEnQ(devPtr,vtI2CMsgTypeSensorInit,0x4F,sizeof(i2cCmdStartConvert),i2cCmdStartConvert,0) != pdTRUE) {
					VT_HANDLE_FATAL_ERROR(0);
				}
			} else 	if (currentState == fsmStateInit2Sent) {
				currentState = fsmStateSensorRead1;
			} else {
				// unexpectedly received this message
				VT_HANDLE_FATAL_ERROR(0);
			}
			break;
		}
		case SensorMsgTypeTimer: {
			// Timer messages never change the state, they just cause an action (or not) 
			if ((currentState != fsmStateInit1Sent) && (currentState != fsmStateInit2Sent)) {
				// Read in the value from the infrared sensor
				if (vtI2CEnQ(devPtr,vtI2CMsgTypeSensorRead1,0x4F,sizeof(i2cCmdReadVals),i2cCmdReadVals,2) != pdTRUE) {
					VT_HANDLE_FATAL_ERROR(0);
				}
			} else {
				// just ignore timer messages until initialization is complete
			} 
			break;
		}
		case vtI2CMsgTypeSensorRead1: {
			if (currentState == fsmStateSensorRead1) {
				distance = getValue(&msgBuffer);
				
				#if PRINTF_VERSION == 1
				printf("Distance %f units\n",distance);
				sprintf(lcdBuffer,"d= %f units",distance);
				#else
				// we do not have full printf (so no %f) and therefore need to print out integers
				printf("Distance %d units\n",lrint(distance));
				sprintf(lcdBuffer,"d=%d units",lrint(distance));
				#endif
				if (lcdData != NULL) {
					if (SendLCDPrintMsg(lcdData,strnlen(lcdBuffer,vtLCDMaxLen),lcdBuffer,portMAX_DELAY) != pdTRUE) {
						VT_HANDLE_FATAL_ERROR(0);
					}
				}
			} else {
				// unexpectedly received this message
				VT_HANDLE_FATAL_ERROR(0);
			}
			break;
		}

		default: {
			VT_HANDLE_FATAL_ERROR(getMsgType(&msgBuffer));
			break;
		}
		}


	}
}